# Keil uVision project rtos.uvproj, settings and files
target Internal Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtos
  c flags: Optim=1
  c misc: --c99
  c include: .\src\lib;.\src\sys
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: rtos.sct
  group scr
    ./src/core/: main.c
  group hal
    ./src/hal/: stack.s system_LPC17xx.c startup_LPC17xx.s
  group lib
    ./src/lib/: snprintf.c
  group isr
    ./src/isr/: svc.c
  group userspace
    ./src/userspace/: userspaceTestProcesses.c
